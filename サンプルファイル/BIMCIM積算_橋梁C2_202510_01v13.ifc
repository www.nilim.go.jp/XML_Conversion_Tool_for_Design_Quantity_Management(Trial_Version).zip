Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-01-09T21:03:12
Author: Takashi Aruga
Organization: buildingSMART Japan
Written by: IfcOpenShell 0.8.0
Made in: IfcOpenShell 0.8.0

# IfcProject, BIMCIM積算サンプルモデル IFC仕様v1.2
Description: IfcPropertySingleValueの単位は、設定の参考例です。; LongName: 事業名

# IfcBeam: コンクリート, 梁部
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_コンクリート - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_コンクリート; 規格_1_コンクリート規格: 1_21－8－25（20）（普通）; 数量: 55.99

# IfcBuildingElementProxy: 均しコンクリート
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_均しコンクリート - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_均しコンクリート; 規格_3_コンクリート規格: 1_21－8－25（20）（普通）; 規格_4_敷厚: 20; 数量: 80.99

# IfcBuildingElementProxy: 型枠 (16)
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_型枠 - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_型枠; 規格_1_型枠の種類: 1_一般型枠
Name | 数量
型枠_1 | 18.7
型枠_2 | 18.7
型枠_3 | 18.26
型枠_4 | 18.26
型枠_5 | 22.5
型枠_6 | 22.5
型枠_11 | 2.64
型枠_12 | 2.64
型枠_7 | 47.1239
型枠_8 | 47.1239
型枠_9 | 25.45
型枠_10 | 25.45
型枠_13 | 8.21399
型枠_14 | 8.21399
型枠_15 | 0.937166
型枠_16 | 0.937166

# IfcBuildingElementProxy: 基礎材
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_基礎材 - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_基礎材; 規格_1_基礎材規格（砕石の場合等）: 1_クラッシャラン40～0; 規格_2_敷厚: 7_27.5cmを超え30.0cm以下; 数量: 80.99

# IfcBuildingElementProxy: 支保 (4)
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_支保 - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_支保; 規格_3_支保耐力: 2_40kN／m2＜f≦60kN／m2［120＜t≦190cm］
Name | 数量
支保_1 | 62.755
支保_2 | 62.755
支保_3 | 7.02875
支保_4 | 7.02875

# IfcBuildingElementProxy: 足場 (8)
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_足場 - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_足場; 規格_1_安全ネットの有無: 1_安全ネット必要
Name | 数量
足場_1 | 23.54
足場_2 | 23.54
足場_3 | 23.1
足場_4 | 23.1
足場_5 | 142
足場_6 | 142
足場_7 | 44
足場_8 | 44

# IfcColumn: コンクリート, 柱部
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_コンクリート - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_コンクリート; 規格_1_コンクリート規格: 1_21－8－25（20）（普通）; 数量: 68.5619

# IfcFooting: コンクリート, フーチング部
In: 橋脚名
工事工種体系_202510_01_道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_コンクリート - 体系コード: 道路新設・改築_橋梁下部_RC橋脚工_橋脚躯体工_コンクリート; 規格_1_コンクリート規格: 5_24－8－25（20）（普通）; 数量: 155.21
